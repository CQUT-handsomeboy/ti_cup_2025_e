# Keil uVision project timer_pwm.uvprojx, settings and files
target timer_pwm (6190000::V6.19::ARMCLANG)
  device: MSPM0L1306 Texas Instruments
  pack: TexasInstruments.MSPM0L11XX_L13XX_DFP.1.3.1
  cpu: IRAM(0x20000000,0x00001000) IROM(0x00000000,0x00010000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: ncontroller +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: __MSPM0L1306__
  c include: ..\source\third_party\CMSIS\Core\Include;..\ndrivers;D:\KEIL5\Packs\ARM\CMSIS-DSP\1.14.2\Include;.\hardware\MPU6050;.\hardware\Grayscale;.\hardware\MPU6050\eMPL;.\hardware;..\..\msp1306_car;..\;..\source
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x1000
  scatter file: .\mspm0l1306.sct
  group Source
    ../source/ti/driverlib/: dl_adc12.c dl_aes.c dl_aesadv.c dl_common.c dl_crc.c dl_crcp.c dl_dac12.c dl_dma.c dl_flashctl.c dl_i2c.c dl_keystorectl.c dl_lcd.c dl_lfss.c dl_mathacl.c dl_mcan.c dl_opa.c dl_rtc_common.c dl_spi.c dl_timer.c dl_trng.c dl_uart.c dl_vref.c
    ../source/ti/driverlib/m0p/: dl_interrupt.c
    ../source/ti/driverlib/m0p/sysctl/: dl_sysctl_mspm0c110x.c dl_sysctl_mspm0g1x0x_g3x0x.c dl_sysctl_mspm0l11xx_l13xx.c dl_sysctl_mspm0l122x_l222x.c
  group ndriver
    ../ndrivers/: drv_oled.c glcdfont.c ssd1306.c drv_i2c.c
  group User
    ../: main.c ncontroller.syscfg ti_msp_dl_config.c ti_msp_dl_config.h gray.c global.h pid.c
    ./: startup_mspm0l1306_uvision.s
    ./hardware/: motor_pwm.c scanline.c lightandsound.h lightandsound.c
    ./hardware/MPU6050/: Delay.c MyI2C.c Kalman.c mpu6050.c
    ./hardware/Grayscale/: mygrayscale.c
